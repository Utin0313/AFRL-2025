options:
  parameters:
    generate_options: qt_gui
    id: Beacon_Positioning
    output_language: python
    title: 'Beacon Based Position Model '
  states: {}

blocks:
- name: F_select
  id: variable_qtgui_chooser
  parameters:
    gui_hint: (0,0,1,1)
    label: Fingerprint Select
    labels: '[''F0'', ''F1'', ''F2'', ''F3'', ''F4'', ''F5'']'
    num_opts: '0'
    options: '[0, 1, 2, 3, 4, 5]'
    type: int
    value: '0'
  states: {}
- name: P0
  id: variable_qtgui_range
  parameters:
    label: Power 0
    start: '0'
    step: '0.05'
    stop: '10'
    value: '1'
  states: {state: disabled}
- name: P1
  id: variable_qtgui_range
  parameters:
    label: Power 1
    start: '0'
    step: '0.05'
    stop: '10'
    value: '2'
  states: {state: disabled}
- name: P2
  id: variable_qtgui_range
  parameters:
    label: Power 2
    start: '0'
    step: '0.05'
    stop: '10'
    value: '3'
  states: {state: disabled}
- name: decim
  id: variable
  parameters:
    value: '20000'
  states: {}
- name: f1_vals
  id: variable
  parameters:
    value: '[0,1,2,3,4,5]'
  states: {}
- name: f2_vals
  id: variable
  parameters:
    value: '[5,4,3,2,1,0]'
  states: {}
- name: f3_vals
  id: variable
  parameters:
    value: '[3,2,4,1,5,0]'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: f1_vals[F_select]
    type: float
  states: {}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    const: f3_vals[F_select]
    type: float
  states: {}
- name: analog_const_source_x_0_0_0
  id: analog_const_source_x
  parameters:
    const: P2
    type: float
  states: {state: disabled}
- name: analog_const_source_x_0_1
  id: analog_const_source_x
  parameters:
    const: f2_vals[F_select]
    type: float
  states: {}
- name: analog_const_source_x_0_1_0
  id: analog_const_source_x
  parameters:
    const: P1
    type: float
  states: {state: disabled}
- name: analog_const_source_x_0_2
  id: analog_const_source_x
  parameters:
    const: P0
    type: float
  states: {state: disabled}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: decim
    type: float
  states: {}
- name: blocks_keep_one_in_n_0_0
  id: blocks_keep_one_in_n
  parameters:
    n: decim
    type: float
  states: {}
- name: blocks_keep_one_in_n_0_1
  id: blocks_keep_one_in_n
  parameters:
    n: decim
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block - max power beacon"""

          def __init__(self): #, example_param=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Beacon-Based Prediction',   # will show up in GRC
                  in_sig=[np.float32,np.float32,np.float32],
                  out_sig=[np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              #self.example_param = example_param

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              in0 = input_items[0]
              in1 = input_items[1]
              in2 = input_items[2]

              n = min(len(in0), len(in1), len(in2), len(output_items[0]))

              for i in range(n):
                  values = [in0[i], in1[i], in2[i]]        # values at this index
                  output_items[0][i] = np.argmax(values)   # write directly to output

              return n
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 1,1,3,2
    label1: Value 2
    label2: Value 1
    label3: Value 0
    max: '6'
    name: '"Input Values"'
    nconnections: '3'
    type: float
  states: {}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_VERT
    gui_hint: (1,0,3,1)
    max: '2.5'
    min: '-0.5'
    name: '"ID Selected"'
    type: float
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_keep_one_in_n_0, '0']
- [analog_const_source_x_0_0, '0', blocks_keep_one_in_n_0_1, '0']
- [analog_const_source_x_0_0_0, '0', epy_block_0, '2']
- [analog_const_source_x_0_0_0, '0', qtgui_number_sink_0, '0']
- [analog_const_source_x_0_1, '0', blocks_keep_one_in_n_0_0, '0']
- [analog_const_source_x_0_1_0, '0', epy_block_0, '1']
- [analog_const_source_x_0_1_0, '0', qtgui_number_sink_0, '1']
- [analog_const_source_x_0_2, '0', epy_block_0, '0']
- [analog_const_source_x_0_2, '0', qtgui_number_sink_0, '2']
- [blocks_keep_one_in_n_0, '0', epy_block_0, '0']
- [blocks_keep_one_in_n_0, '0', qtgui_number_sink_0, '2']
- [blocks_keep_one_in_n_0_0, '0', epy_block_0, '1']
- [blocks_keep_one_in_n_0_0, '0', qtgui_number_sink_0, '1']
- [blocks_keep_one_in_n_0_1, '0', epy_block_0, '2']
- [blocks_keep_one_in_n_0_1, '0', qtgui_number_sink_0, '0']
- [blocks_throttle2_0, '0', qtgui_number_sink_1, '0']
- [epy_block_0, '0', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
